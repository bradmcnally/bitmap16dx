#include "core/canvas.h"

#include <algorithm>
#include <cstdlib>
#include <cstring>
#include <limits>
#include <new>

namespace bitmap16 {

namespace {

// Printable ASCII 32-126, stored as five vertical 7-bit columns per glyph.
constexpr uint8_t kFont5x7[][5] = {
    {0x00,0x00,0x00,0x00,0x00},{0x00,0x00,0x5f,0x00,0x00},
    {0x00,0x07,0x00,0x07,0x00},{0x14,0x7f,0x14,0x7f,0x14},
    {0x24,0x2a,0x7f,0x2a,0x12},{0x23,0x13,0x08,0x64,0x62},
    {0x36,0x49,0x55,0x22,0x50},{0x00,0x05,0x03,0x00,0x00},
    {0x00,0x1c,0x22,0x41,0x00},{0x00,0x41,0x22,0x1c,0x00},
    {0x08,0x2a,0x1c,0x2a,0x08},{0x08,0x08,0x3e,0x08,0x08},
    {0x00,0x50,0x30,0x00,0x00},{0x08,0x08,0x08,0x08,0x08},
    {0x00,0x60,0x60,0x00,0x00},{0x20,0x10,0x08,0x04,0x02},
    {0x3e,0x51,0x49,0x45,0x3e},{0x00,0x42,0x7f,0x40,0x00},
    {0x42,0x61,0x51,0x49,0x46},{0x21,0x41,0x45,0x4b,0x31},
    {0x18,0x14,0x12,0x7f,0x10},{0x27,0x45,0x45,0x45,0x39},
    {0x3c,0x4a,0x49,0x49,0x30},{0x01,0x71,0x09,0x05,0x03},
    {0x36,0x49,0x49,0x49,0x36},{0x06,0x49,0x49,0x29,0x1e},
    {0x00,0x36,0x36,0x00,0x00},{0x00,0x56,0x36,0x00,0x00},
    {0x00,0x08,0x14,0x22,0x41},{0x14,0x14,0x14,0x14,0x14},
    {0x41,0x22,0x14,0x08,0x00},{0x02,0x01,0x51,0x09,0x06},
    {0x32,0x49,0x79,0x41,0x3e},{0x7e,0x11,0x11,0x11,0x7e},
    {0x7f,0x49,0x49,0x49,0x36},{0x3e,0x41,0x41,0x41,0x22},
    {0x7f,0x41,0x41,0x22,0x1c},{0x7f,0x49,0x49,0x49,0x41},
    {0x7f,0x09,0x09,0x01,0x01},{0x3e,0x41,0x41,0x51,0x32},
    {0x7f,0x08,0x08,0x08,0x7f},{0x00,0x41,0x7f,0x41,0x00},
    {0x20,0x40,0x41,0x3f,0x01},{0x7f,0x08,0x14,0x22,0x41},
    {0x7f,0x40,0x40,0x40,0x40},{0x7f,0x02,0x04,0x02,0x7f},
    {0x7f,0x04,0x08,0x10,0x7f},{0x3e,0x41,0x41,0x41,0x3e},
    {0x7f,0x09,0x09,0x09,0x06},{0x3e,0x41,0x51,0x21,0x5e},
    {0x7f,0x09,0x19,0x29,0x46},{0x46,0x49,0x49,0x49,0x31},
    {0x01,0x01,0x7f,0x01,0x01},{0x3f,0x40,0x40,0x40,0x3f},
    {0x1f,0x20,0x40,0x20,0x1f},{0x7f,0x20,0x18,0x20,0x7f},
    {0x63,0x14,0x08,0x14,0x63},{0x03,0x04,0x78,0x04,0x03},
    {0x61,0x51,0x49,0x45,0x43},{0x00,0x00,0x7f,0x41,0x41},
    {0x02,0x04,0x08,0x10,0x20},{0x41,0x41,0x7f,0x00,0x00},
    {0x04,0x02,0x01,0x02,0x04},{0x40,0x40,0x40,0x40,0x40},
    {0x00,0x01,0x02,0x04,0x00},{0x20,0x54,0x54,0x54,0x78},
    {0x7f,0x48,0x44,0x44,0x38},{0x38,0x44,0x44,0x44,0x20},
    {0x38,0x44,0x44,0x48,0x7f},{0x38,0x54,0x54,0x54,0x18},
    {0x08,0x7e,0x09,0x01,0x02},{0x08,0x14,0x54,0x54,0x3c},
    {0x7f,0x08,0x04,0x04,0x78},{0x00,0x44,0x7d,0x40,0x00},
    {0x20,0x40,0x44,0x3d,0x00},{0x00,0x7f,0x10,0x28,0x44},
    {0x00,0x41,0x7f,0x40,0x00},{0x7c,0x04,0x18,0x04,0x78},
    {0x7c,0x08,0x04,0x04,0x78},{0x38,0x44,0x44,0x44,0x38},
    {0x7c,0x14,0x14,0x14,0x08},{0x08,0x14,0x14,0x18,0x7c},
    {0x7c,0x08,0x04,0x04,0x08},{0x48,0x54,0x54,0x54,0x20},
    {0x04,0x3f,0x44,0x40,0x20},{0x3c,0x40,0x40,0x20,0x7c},
    {0x1c,0x20,0x40,0x20,0x1c},{0x3c,0x40,0x30,0x40,0x3c},
    {0x44,0x28,0x10,0x28,0x44},{0x0c,0x50,0x50,0x50,0x3c},
    {0x44,0x64,0x54,0x4c,0x44},{0x00,0x08,0x36,0x41,0x00},
    {0x00,0x00,0x7f,0x00,0x00},{0x00,0x41,0x36,0x08,0x00},
    {0x08,0x08,0x2a,0x1c,0x08},
};

uint16_t swap16(uint16_t value) {
  return static_cast<uint16_t>((value >> 8) | (value << 8));
}

}  // namespace

Canvas::~Canvas() {
  release();
}

bool Canvas::create(int width, int height) {
  release();
  if (width <= 0 || height <= 0) {
    return false;
  }
  const std::size_t widthSize = static_cast<std::size_t>(width);
  const std::size_t heightSize = static_cast<std::size_t>(height);
  if (widthSize >
      std::numeric_limits<std::size_t>::max() / heightSize / sizeof(uint16_t)) {
    return false;
  }
  const std::size_t count = widthSize * heightSize;
  pixels_ = new (std::nothrow) uint16_t[count];
  if (pixels_ == nullptr) {
    return false;
  }
  width_ = width;
  height_ = height;
  return true;
}

void Canvas::release() {
  delete[] pixels_;
  pixels_ = nullptr;
  width_ = 0;
  height_ = 0;
}

void Canvas::fillScreen(uint16_t color) {
  if (pixels_ == nullptr) return;
  std::fill(
      pixels_,
      pixels_ + static_cast<std::size_t>(width_) * height_,
      color);
}

void Canvas::drawPixel(int x, int y, uint16_t color) {
  if (pixels_ != nullptr && x >= 0 && y >= 0 && x < width_ && y < height_) {
    pixels_[static_cast<std::size_t>(y) * width_ + x] = color;
  }
}

uint16_t Canvas::readPixel(int x, int y, uint16_t fallback) const {
  if (pixels_ == nullptr || x < 0 || y < 0 || x >= width_ || y >= height_) {
    return fallback;
  }
  return pixels_[static_cast<std::size_t>(y) * width_ + x];
}

void Canvas::fillRect(
    int x,
    int y,
    int width,
    int height,
    uint16_t color) {
  if (pixels_ == nullptr || width <= 0 || height <= 0) return;
  const int left = std::max(0, x);
  const int top = std::max(0, y);
  const int right = std::min(width_, x + width);
  const int bottom = std::min(height_, y + height);
  if (left >= right || top >= bottom) return;
  for (int row = top; row < bottom; ++row) {
    uint16_t* start = pixels_ + static_cast<std::size_t>(row) * width_ + left;
    std::fill(start, start + (right - left), color);
  }
}

void Canvas::drawRect(
    int x,
    int y,
    int width,
    int height,
    uint16_t color) {
  if (width <= 0 || height <= 0) return;
  drawFastHLine(x, y, width, color);
  drawFastHLine(x, y + height - 1, width, color);
  drawFastVLine(x, y, height, color);
  drawFastVLine(x + width - 1, y, height, color);
}

void Canvas::drawFastHLine(int x, int y, int width, uint16_t color) {
  fillRect(x, y, width, 1, color);
}

void Canvas::drawFastVLine(int x, int y, int height, uint16_t color) {
  fillRect(x, y, 1, height, color);
}

void Canvas::drawLine(
    int x0,
    int y0,
    int x1,
    int y1,
    uint16_t color) {
  const int dx = std::abs(x1 - x0);
  const int stepX = x0 < x1 ? 1 : -1;
  const int dy = -std::abs(y1 - y0);
  const int stepY = y0 < y1 ? 1 : -1;
  int error = dx + dy;

  while (true) {
    drawPixel(x0, y0, color);
    if (x0 == x1 && y0 == y1) break;
    const int doubled = error * 2;
    if (doubled >= dy) {
      error += dy;
      x0 += stepX;
    }
    if (doubled <= dx) {
      error += dx;
      y0 += stepY;
    }
  }
}

void Canvas::pushImage(
    int x,
    int y,
    int width,
    int height,
    const uint16_t* image,
    bool swapBytes) {
  if (pixels_ == nullptr || image == nullptr || width <= 0 || height <= 0) {
    return;
  }
  for (int sourceY = 0; sourceY < height; ++sourceY) {
    for (int sourceX = 0; sourceX < width; ++sourceX) {
      uint16_t color =
          image[static_cast<std::size_t>(sourceY) * width + sourceX];
      if (swapBytes) color = swap16(color);
      drawPixel(x + sourceX, y + sourceY, color);
    }
  }
}

int Canvas::textWidth(const char* text) const {
  if (text == nullptr) return 0;
  return static_cast<int>(std::strlen(text)) * 6 * textSize_;
}

void Canvas::drawString(const char* text, int x, int y) {
  if (text == nullptr) return;
  int cursorX = x;
  const int width = textWidth(text);
  if (textAlign_ == TextAlign::Center) cursorX -= width / 2;
  if (textAlign_ == TextAlign::Right) cursorX -= width;

  for (const char* character = text; *character != '\0'; ++character) {
    uint8_t code = static_cast<uint8_t>(*character);
    if (code < 32 || code > 126) code = '?';
    const uint8_t* glyph = kFont5x7[code - 32];
    for (int column = 0; column < 5; ++column) {
      for (int row = 0; row < 7; ++row) {
        if ((glyph[column] & (1 << row)) != 0) {
          fillRect(
              cursorX + column * textSize_,
              y + row * textSize_,
              textSize_,
              textSize_,
              textColor_);
        }
      }
    }
    cursorX += 6 * textSize_;
  }
}

}  // namespace bitmap16
